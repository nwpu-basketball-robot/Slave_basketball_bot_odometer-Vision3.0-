# Keil uVision project basketball_code.uvprojx, settings and files
target basketball_odometer (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: basketball_code +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\sys;..\SYSTEM\delay;..\USER;..\FWLIB\inc;..\INIT\TIMER;..\INIT\LED;..\TF;..\HANDLE;..\INIT\USART1;..\IMU1500;..\INIT\UART4;..\INIT\NVIC;..\INIT\USART2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group INIT
    ../INIT/LED/: led.c
    ../INIT/TIMER/: timer.c
    ../INIT/USART1/: usart1.c
    ../INIT/UART4/: uart4.c
    ../INIT/NVIC/: nvic.c
    ../INIT/USART2/: usart2.c
  group FELIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group TF
    ../TF/: transform.c
  group HANDLE
    ../HANDLE/: handle.c
  group IMU_HANDLE
    ../IMU1500/: imu1500.c
  group README
    ../: readme.txt
